# Keil uVision project intelligent-watch.uvprojx, settings and files
target intelligent-watch (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3") TZ
  output: intelligent-watch +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F103xB
  c include: ../Core/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F1xx/Include;../Drivers/CMSIS/Include;../Hardware
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Application/MDK-ARM
    ./: startup_stm32f103xb.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c i2c.c stm32f1xx_it.c stm32f1xx_hal_msp.c
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Inc/: stm32_assert_template.h stm32f1xx_hal.h stm32f1xx_hal_adc.h stm32f1xx_hal_adc_ex.h stm32f1xx_hal_can.h stm32f1xx_hal_cec.h stm32f1xx_hal_conf_template.h stm32f1xx_hal_cortex.h stm32f1xx_hal_crc.h stm32f1xx_hal_dac.h stm32f1xx_hal_dac_ex.h stm32f1xx_hal_def.h stm32f1xx_hal_dma.h stm32f1xx_hal_dma_ex.h stm32f1xx_hal_eth.h stm32f1xx_hal_exti.h stm32f1xx_hal_flash.h stm32f1xx_hal_flash_ex.h stm32f1xx_hal_gpio.h stm32f1xx_hal_gpio_ex.h stm32f1xx_hal_hcd.h stm32f1xx_hal_i2c.h stm32f1xx_hal_i2s.h stm32f1xx_hal_irda.h stm32f1xx_hal_iwdg.h stm32f1xx_hal_mmc.h stm32f1xx_hal_nand.h stm32f1xx_hal_nor.h stm32f1xx_hal_pccard.h stm32f1xx_hal_pcd.h stm32f1xx_hal_pcd_ex.h stm32f1xx_hal_pwr.h stm32f1xx_hal_rcc.h stm32f1xx_hal_rcc_ex.h stm32f1xx_hal_rtc.h stm32f1xx_hal_rtc_ex.h stm32f1xx_hal_sd.h stm32f1xx_hal_smartcard.h stm32f1xx_hal_spi.h stm32f1xx_hal_sram.h stm32f1xx_hal_tim.h stm32f1xx_hal_tim_ex.h stm32f1xx_hal_uart.h stm32f1xx_hal_usart.h stm32f1xx_hal_wwdg.h stm32f1xx_ll_adc.h stm32f1xx_ll_bus.h stm32f1xx_ll_cortex.h stm32f1xx_ll_crc.h stm32f1xx_ll_dac.h stm32f1xx_ll_dma.h stm32f1xx_ll_exti.h stm32f1xx_ll_fsmc.h stm32f1xx_ll_gpio.h stm32f1xx_ll_i2c.h stm32f1xx_ll_iwdg.h stm32f1xx_ll_pwr.h stm32f1xx_ll_rcc.h stm32f1xx_ll_rtc.h stm32f1xx_ll_sdmmc.h stm32f1xx_ll_spi.h stm32f1xx_ll_system.h stm32f1xx_ll_tim.h stm32f1xx_ll_usart.h stm32f1xx_ll_usb.h stm32f1xx_ll_utils.h stm32f1xx_ll_wwdg.h
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_i2c.c stm32f1xx_hal.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_dma.c stm32f1xx_hal_cortex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_exti.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f1xx.c
  group Hardware
    ../Hardware/: OLED.c OLED.h OLED_Data.c OLED_Data.h Key.h Key.cpp
software components: CMSIS:CORE 4.3.0
